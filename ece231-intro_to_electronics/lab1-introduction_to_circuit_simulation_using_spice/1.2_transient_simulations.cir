** 1.1 Transient Simulations **
*
* NI Multisim to SPICE Netlist Export
* Generated by: barne
* Mon, Jan 21, 2019 15:35:24
*

*## Multisim Component V1 ##*
vV1 Vin 0 ac 1 0
+   distof1 0 0
+   distof2 0 0
+   pulse(0 1 0 1e-009 1e-009 0.005 0.01)

*## Multisim Component C1 ##*
cC1 Vout 0 1e-006

*## Multisim Component R1 ##*
rR1 Vin Vout 1000 vresR1
.model vresR1 r(  )
